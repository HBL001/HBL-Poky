FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-auto-program-eeprom-on-first-boot.patch"
SRC_URI += "file://0002-am335x-boneblack-flip-sd-card-detect-logic.patch"

